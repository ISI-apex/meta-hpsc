# Use our config file(s) instead of the original(s)

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
