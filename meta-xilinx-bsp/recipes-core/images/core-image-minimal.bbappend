IMAGE_INSTALL += " libgomp libgomp-dev libgomp-staticdev mpich libc-staticdev gdbserver openssh openssh-sftp-server libstdc++ util-linux"
